# Keil uVision project CNS.uvprojx, settings and files
target CNS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CNS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\USER;..\CORE;..\BSP;..\CNS_CORE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CNS_CORE
    ../CNS_CORE/: cns_core.c cns_action.c cns_action.h cns_event.c cns_event.h
  group BSP
    ../BSP/: spi.c timer.c usart.c rtc.c stmflash.c
